# Keil uVision project LAB1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: LAB1 +hex
  c flags: Optimize=2
  group Source Group 1
    ./: test.c
